SRC_URI:remove:aarch64 = "file://0001-gst-plugins-good-stubs-soft.h-not-existing-error.patch"
SRC_URI:remove:x86-64 = "file://0001-gst-plugins-good-stubs-soft.h-not-existing-error.patch"
