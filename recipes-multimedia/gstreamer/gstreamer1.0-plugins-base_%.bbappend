SRC_URI:remove:aarch64 = "file://0001-gst-plugins-base-stubs-soft.h-not-existing-compilati.patch"
SRC_URI:remove:x86-64 = "file://0001-gst-plugins-base-stubs-soft.h-not-existing-compilati.patch"
