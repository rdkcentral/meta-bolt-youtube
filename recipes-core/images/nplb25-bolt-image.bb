SUMMARY = "NPLB bolt image"

require cobalt-common.inc

IMAGE_INSTALL += "nplb-25.lts.stable"
IMAGE_INSTALL += "nplb-25.lts.stable-test-data"
IMAGE_INSTALL += "nplb-launcher"
