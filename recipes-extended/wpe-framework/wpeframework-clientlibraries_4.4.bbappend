DISTRO_FEATURES:remove = "opencdm"
DISTRO_FEATURES:append = " enable_icrypto_openssl"
