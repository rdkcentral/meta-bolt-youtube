FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-RDKEAPPRT-615-Add-experimental-actions-interface.patch"
