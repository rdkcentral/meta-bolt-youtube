REQUIRED_DISTRO_FEATURES:remove = "cobalt-27"

PROVIDES:remove = "virtual/cobalt-evergreen"
RPROVIDES:${PN}:remove = "virtual/cobalt-evergreen"

PROVIDES = "virtual/cobalt-evergreen-27"
RPROVIDES:${PN} = "virtual/cobalt-evergreen-27"
